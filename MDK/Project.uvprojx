# Keil uVision project Project.uvprojx, settings and files
target Randle_H (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER\inc;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\Device;..\BSP;..\Libraries\Glucoo;..\Libraries\Glucoo\BlackHouse;..\Libraries\Glucoo\STB;..\Libraries\Glucoo\Font
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c
    ../USER/src/: stm32f10x_it.c delay.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/src/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/startup/arm/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/: ssd1306.c
  group Glucoo
    ../Libraries/Glucoo/: RH_gui.c RH_gui_api.c
  group BlackHouse
    ../Libraries/Glucoo/BlackHouse/: RH_data.c RH_dsp.c RH_graphic.c RH_image.c RH_lib.c RH_math.c RH_time.c RH_utility.c RH_common.h RH_config.h
  group Font
    ../Libraries/Glucoo/Font/: RH_font.h RH_font.c RH_font_ArialRoundedBold.c
  group STB
    ../Libraries/Glucoo/STB/: stb_truetype.h
