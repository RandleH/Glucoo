# Keil uVision project Project.uvprojx, settings and files
target Randle_H (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177 --diag_suppress=1035
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport\startup;..\User\inc;..\Libraries\CMSIS\CM4\DeviceSupport;..\BSP\inc;..\..\core\BlackHouse;..\..\core\Font;..\..\core\STB;..\..\core;..\self
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c
    ../User/src/: delay.c stm32f4xx_it.c sys.c
    ../self/: RH_gui_api.c
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM4/DeviceSupport/: system_stm32f4xx.c
  group Startup
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/: startup_stm32f40_41xxx.s
  group BSP
    ../BSP/src/: ssd1351.c
  group Font
    ../../core/Font/: RH_font.c RH_font_ArialRoundedBold.c RH_font_CourierNew.c RH_font_CourierNewBold.c
  group STB
    ../../core/STB/: stb_truetype.h
  group BlackHouse
    ../../core/BlackHouse/: RH_data.c RH_dsp.c RH_graphic.c RH_image.c RH_lib.c RH_math.c RH_time.c RH_utility.c
  group Glucoo
    ../../core/: RH_gui.c
