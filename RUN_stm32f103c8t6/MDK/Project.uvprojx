# Keil uVision project Project.uvprojx, settings and files
target Randle_H (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_ASSERT
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER\inc;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\Device;..\BSP;..\..\core\BlackHouse;..\..\core\STB;..\self;..\..\core;..\Libraries\CMSIS\CM3\CoreSupport;..\..\core\Glucoo;..\..\core\Glucoo\draw;..\..\core\Glucoo\menu;..\..\core\Glucoo\object;..\..\core\Glucoo\window;..\..\core\Glucoo\font
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/src/: stm32f10x_it.c delay.c
    ../USER/: main.c
    ../User/src/: isr.c
    ../self/: GLU_api.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/src/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/startup/arm/: startup_stm32f10x_hd.s
  group BSP
    ../BSP/: ssd1306.c joystick.c led.c beeper.c
  group Glucoo
    ../../core/Glucoo/: GLU_glucoo.c
    ../../core/Glucoo/draw/: GLU_draw.c
    ../../core/Glucoo/window/: GLU_window.c
    ../../core/Glucoo/object/: GLU_object.c
    ../../core/Glucoo/menu/: GLU_menu.c
    ../../core/Glucoo/font/: GLU_font.c GLU_font_ArialRoundedBold.c GLU_font_CourierNew.c GLU_font_CourierNewBold.c
  group STB
    ../../core/STB/: stb_truetype.h
  group BlackHouse
    ../../core/BlackHouse/: BLK_data.c BLK_dsp.c BLK_graphic.c BLK_image.c BLK_lib.c BLK_math.c BLK_time.c BLK_utility.c
